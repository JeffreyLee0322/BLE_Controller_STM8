# IAR project Backup of Demo_stm8v01.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x200
  General.GenHeapSize: 0x200
  ICCSTM8.CCDefines: STM8L15X_MD; DEBUG_EN
  ICCSTM8.CCIncludePath2: ..\Libraries\STM8L15x_StdPeriph_Driver\inc; inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Backup of Demo_stm8v01.bin
  ILINK.IlinkOutputFile: Demo_stm8v01.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG; ENHANCE_MODE; STM8L15X_MD
  group user
    src/: App.c APPSub.c BIOS.c Delay.c Key.c LED.c main.c RF.c RFAPI.c stm8l15x_it.c
  group user/Library
    ../Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_pwr.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_usart.c stm8l15x_wfe.c
